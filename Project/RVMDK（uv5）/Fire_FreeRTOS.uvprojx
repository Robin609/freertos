# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=3 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\Key;..\..\User\usart;..\..\User\as608;..\..\User\delay;..\..\User\SYS;..\..\User\RT_Delay;..\..\User\matrix_key;..\..\User\hc_sr04\System_Init;..\..\User\hc_sr04\SysTick;..\..\User\hc_sr04\timer;..\..\User\hc_sr04\ULTRASONIC;..\..\User\LCD_1.8_ST7735
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
    ../../User/Led/: bsp_led.c
    ../../User/usart/: bsp_usart.c rx_data_queue.c
    ../../User/Key/: bsp_key.c
    ../../User/as608/: as608_test.c bsp_as608.c
    ../../User/delay/: delay.c
    ../../User/SYS/: sys.c
    ../../User/RT_Delay/: RT_Delay.c
    ../../User/matrix_key/: matrix_key.c
    ../../User/hc_sr04/System_Init/: System_Init.c
    ../../User/hc_sr04/timer/: timer.c
    ../../User/hc_sr04/ULTRASONIC/: ultrasonic.c
    ../../User/LCD_1.8_ST7735/: lcd_st7735.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group DOC
    ../../Doc/: readme.txt
